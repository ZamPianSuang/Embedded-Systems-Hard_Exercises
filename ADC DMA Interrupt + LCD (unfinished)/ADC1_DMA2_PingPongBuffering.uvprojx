# Keil uVision project ADC1_DMA2_PingPongBuffering.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC1_DMA2_PingPongBuffering +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: ADC1_DMA2_Interrupt_DoubleBf.c ADC1_DMA2_Interrupt_DoubleBf.h LCD_20x4_4bits.c LCD_20x4_4bits.h main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
